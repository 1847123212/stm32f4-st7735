# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\ZLCR\Firmware\lib\stm32f4\Inc;..\ZLCR\Firmware\lib\cmsis\CMSIS\Include;..\ZLCR\Firmware\lib\stm32f4\Inc\Legacy;.\st7735;.\Inc;..\ZLCR\STM32\STM32F103RBT6\User\image
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
    ../ZLCR/Firmware/ZLCR_beta_freertos/MDK/: startup_stm32f411xe.s
  group New Group1
    ./st7735/: fonts.c st7735.c
    ../ZLCR/STM32/STM32F103RBT6/User/image/: image.c image2.c
  group New Group
    ../ZLCR/Firmware/lib/stm32f4/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c
